# Keil uVision project lesson.uvprojx, settings and files
target dbg (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: .;..\qpc\include;..\qpc\ports\arm-cm\qk\armclang;..\ek-tm4c123gxl;..\CMSIS\Include
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: lesson.sct
  group Source
    ./: main.c bsp.c bsp.h qp_config.h app.h periodic1.c periodic4.c sporadic2.c sporadic3.c
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
    ../ek-tm4c123gxl/: README.txt system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
  group CMSIS
    ../CMSIS/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h
  group qpc
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qmact.c qf_qact.c qf_qeq.c qf_time.c
    ../qpc/src/qk/: qk.c
    ../qpc/ports/arm-cm/qk/armclang/: qk_port.c qp_port.h qs_port.h
